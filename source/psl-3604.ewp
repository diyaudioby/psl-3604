# IAR project psl-3604.ewp, settings and files
configuration PSL-3604 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x8 ST STM32F100x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD_VL
  ICCARM.CCIncludePath2: Source\Sys\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: psl-3604.hex
  ILINK.IlinkOutputFile: psl-3604.out
  ILINK.IlinkIcfFile: D:\Projects\Proj_Spetspribor\Power_Supplies\PSL-3604\Firmware\psl-3604.icf
  ILINK.IlinkExtraOptions: --basic_heap
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    Source/: analog.cpp control.cpp data.cpp display.cpp eeprom.cpp encoder.cpp fan.cpp i2csw.cpp keyboard.cpp main.cpp menu.cpp port.cpp sound.cpp sreg.cpp systimer.cpp therm.cpp wake.cpp wakeport.cpp
  group Sys
    Source/Sys/: startup_stm32f10x_md_vl.s stm32f10x.h
